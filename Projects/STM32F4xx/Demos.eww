<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\bootloader\EWARM\Bootloader.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\COM.Apple.HomeKit\EWARM\COM.Apple.HomeKit.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\COM.MXCHIP.BASIC\EWARM\COM.MXCHIP.BASIC.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\COM.MXCHIP.SPP\EWARM\COM.MXCHIP.SPP.ewp</path>
  </project>
   <project>
    <path>$WS_DIR$\COM.MXCHIP.FogCloud\EWARM\COM.MXCHIP.FogCloud.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\COM.WECHAT.SPP\EWARM\COM.WECHAT.SPP.ewp</path>
  </project>
   <project>
    <path>$WS_DIR$\COM.MXCHIP.MicoKit\EWARM\COM.MXCHIP.MicoKit.ewp</path>
  </project>
  <batchBuild/>
</workspace>


