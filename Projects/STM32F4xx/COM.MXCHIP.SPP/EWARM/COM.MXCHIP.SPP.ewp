# IAR project COM.MXCHIP.SPP.ewp, settings and files
configuration MiCOKit-3165 (ARM)
  General.OGChipSelectEditMenu: STM32F411CE ST STM32F411CE
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=26000000
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-3165; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: COM.MXCHIP.SPP.bin
  ILINK.IlinkOutputFile: COM.MXCHIP.SPP.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3165\micoLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MiCOKit-3288 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=16000000
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-3288; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\Drivers\rgb_led; ..\..\..\..\Platform\Drivers\MiCOKit_EXT
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3288\micoLinkerForIAR.icf
configuration EMW5288 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=16000000
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\EMW5288; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash
  ILINK.IlinkIcfFile: ..\..\..\..\Board\EMW5288\micoLinkerForIAR.icf
configuration MiCOKit-F411B (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=16000000
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-F411B; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-F411B\micoLinkerForIAR.icf
configuration MiCOKit-F411A (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; HSE_VALUE=16000000
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-F411A; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\Drivers\rgb_led
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-F411A\micoLinkerForIAR.icf
configuration EMW3265 (ARM)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\..\..\Demos\COM.MXCHIP.SPP; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\EMW3265; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M4; ..\..\..\..\Platform\Cortex-M4\CMSIS; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries\STM32F4xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F4xx\peripherals\Libraries; ..\..\..\..\Platform\Drivers\spi_flash
  ILINK.IlinkIcfFile: ..\..\..\..\Board\EMW3265\micoLinkerForIAR.icf
  group Application
    ../../../../Demos/COM.MXCHIP.SPP/: LocalTcpServer.c MICOAppDefine.h MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c MicoDefaults.h RemoteTcpClient.c SppProtocol.c UartRecv.c
  group Board/EMW3265
    ../../../../Board/EMW3265/: platform.c platform.h platform_config.h wifi_nvram.c wifi_nvram_image.h
  group Board/EMW5288
    ../../../../Board/EMW5288/: platform.c platform.h platform_common_config.h platform_spi_flash.c
  group Board/MiCOKit-3165
    ../../../../Board/MiCOKit-3165/: platform.c platform.h platform_config.h
  group Board/MiCOKit-3288
    ../../../../Board/MiCOKit-3288/: platform.c platform.h platform_config.h
  group Board/MiCOKit-F411A
    ../../../../Board/MiCOKit-F411A/: platform.c platform.h platform_config.h
  group Board/MiCOKit-F411B
    ../../../../Board/MiCOKit-F411B/: platform.c platform.h platform_config.h
  group External/Curve25519
    ../../../../External/Curve25519/: curve25519-donna.c
  group External/FatFs/Core
    ../../../../External/FatFs/src/: diskio.c ff.c ff_gen_drv.c
  group External/FatFs/Drivers
    ../../../../External/FatFs/src/drivers/: usbh_diskio.c
  group External/FatFs/Options
    ../../../../External/FatFs/src/option/: syscall.c unicode.c
  group External/GladmanAES
    ../../../../External/GladmanAES/: aes_modes.c aescrypt.c aeskey.c aestab.c gf128mul.c
  group External/JSON-C
    ../../../../External/JSON-C/: arraylist.c debug.c json.h json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group External/SHAUtils
    ../../../../External/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/MicoDriver
    ../../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group Library
    ../../../../MICO/Library/: MICOConfig.c mxchipWNet_cm4f_8801.a mxchipWNet_cm4f_sdio.a
    ../../../../MICO/Library/RF driver/: wlan_firmware.c
  group MICO
    ../../../../MICO/: MICOCli.c MICOConfigMenu.c MICOConfigServer.c MICODefine.h MICOEntrance.c MICOMfgtest.c MICONotificationCenter.c MICONTPClient.c MICOParaStorage.c MICOSystemMonitor.c
  group MICO/AirKiss
    ../../../../MICO/Airkiss/: Airkiss.c Airkiss_CM3_Debug.a Airkiss_CM3_Release.a
  group MICO/EasyLink
    ../../../../MICO/EasyLink/: EasyLink.c
    ../../../../MICO/SoftAP/: EasyLinkSoftAP.c
  group MICO/WAC
    ../../../../MICO/WAC/: MFi_WAC_CM3_Debug.a MFi_WAC_CM3_Release.a
  group MICO/WPS
    ../../../../MICO/WPS/: WPS.c
  group Platform
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/Cortex-M4
    ../../../../Platform/Cortex-M4/: crt0_EWARM.c hardfault.c
  group Platform/Drivers/MiCOKit-EXT
    ../../../../Platform/Drivers/MiCOKit_EXT/: micokit_ext.c micokit_ext.h micokit_ext_def.h micokit_ext_mfg.c
  group Platform/Drivers/MiCOKit-EXT/sensors/dc_motor
    ../../../../Platform/Drivers/MiCOKit_EXT/dc_motor/: dc_motor.c dc_motor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/infrared_reflective
    ../../../../Platform/Drivers/MiCOKit_EXT/infrared_reflective/: infrared_reflective.c infrared_reflective.h
  group Platform/Drivers/MiCOKit-EXT/sensors/key
    ../../../../Platform/Drivers/MiCOKit_EXT/key/: keys.c keys.h
  group Platform/Drivers/MiCOKit-EXT/sensors/lcd
    ../../../../Platform/Drivers/MiCOKit_EXT/lcd/: AsciiLib.c AsciiLib.h oled.c oled.h oledfont.h
  group Platform/Drivers/MiCOKit-EXT/sensors/light
    ../../../../Platform/Drivers/MiCOKit_EXT/light/: light_sensor.c light_sensor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/rgb_led
    ../../../../Platform/Drivers/MiCOKit_EXT/rgb_led/: hsb2rgb_led.c hsb2rgb_led.h rgb_led.c rgb_led.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor
    ../../../../Platform/Drivers/MiCOKit_EXT/temp_hum_sensor/: temp_hum_sensor.c temp_hum_sensor.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor/BME280
    ../../../../Platform/Drivers/MiCOKit_EXT/temp_hum_sensor/BME280/: bme280.c bme280.h bme280_user.c bme280_user.h
  group Platform/Drivers/MiCOKit-EXT/sensors/temp_hum_sensor/DHT11
    ../../../../Platform/Drivers/MiCOKit_EXT/temp_hum_sensor/DHT11/: DHT11.c DHT11.h
  group Platform/Drivers/SPI Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/EWARM
    ../../../../Platform/EWARM/: Retarget.c
  group Platform/STM32F4xx
    ../../../../Platform/MCU/STM32F4xx/: platform_init.c
  group Platform/STM32F4xx/EWARM
    ../../../../Platform/MCU/STM32F4xx/EWARM/: startup_stm32f411xe_IAR.s
  group Platform/STM32F4xx/Peripherals
    ../../../../Platform/MCU/STM32F4xx/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/STM32F4xx/Peripherals/Libraries
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/: system_stm32f4xx.c
  group Platform/STM32F4xx/Peripherals/Libraries/STM32F4xx_StdPeriph_Driver
    ../../../../Platform/MCU/STM32F4xx/peripherals/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group Platform/STM32F4xx/Wi-Fi_Bus_Driver
    ../../../../Platform/MCU/STM32F4xx/wlan_bus_driver/: read_wifi_firmware.c wlan_bus_sdio.c wlan_bus_spi.c wlan_platform.c
  group Support
    ../../../../Support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
