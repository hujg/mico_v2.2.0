# Keil uVision project COM.WECHAT.SPP.uvprojx, settings and files
target MiCOKit-3162 (ARM-ADS)
  device: STM32F205RGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: COM.WECHAT.SPP.axf
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin  ..\..\..\..\Build\COM.WECHAT.SPP\MiCOKit-3162\Obj_RVMDK\COM.WECHAT.SPP.axf --output ..\..\..\..\Build\COM.WECHAT.SPP\Output\MiCOKit-3162\COM.WECHAT.SPP.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER DEBUG
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\Demos\COM.WECHAT.SPP;..\..\..\..\include;..\..\..\..\include\EasyCloud;..\..\..\..\MICO;..\..\..\..\Support;..\..\..\..\External;..\..\..\..\Board\MiCOKit-3162;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\MCU\STM32F2xx\peripherals;..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries;..\..\..\..\Platform\Drivers\spi_flash
  memory RVCT4: ROM 0x800c000 size 0xf4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
  group Application
    ../../../../Demos/COM.WECHAT.SPP/: MICOAppEntrance.c MICOBonjour.c MICOConfigDelegate.c MicoVirtualDevice.c MVDCloudInterfaces.c MVDDeviceInterfaces.c
  group Include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group Board/MiCOKit-3162
    ../../../../Board/MiCOKit-3162/: platform.c platform.h
    ../../../../Board/MiCOKit-3165/: platform_config.h
  group Board/MiCOKit-F205
    ../../../../Board/MiCOKit-F205/: platform.c platform.h platform_config.h
  group MICO
    ../../../../MICO/: MICOConfigMenu.c MICOConfigServer.c MICOEntrance.c MICONotificationCenter.c MICONTPClient.c MICOSystemMonitor.c MICOParaStorage.c MICOMfgtest.c MICOCli.c MICODefine.h
    ../../../../MICO/EasyLink/: EasyLink.c
    ../../../../MICO/SoftAP/: EasyLinkSoftAP.c
    ../../../../MICO/WPS/: WPS.c
    ../../../../MICO/WAC/: MFi_WAC_CM3_Debug.a
    ../../../../MICO/Airkiss/: Airkiss.c Airkiss_CM3_Debug.a Airkiss_CM3_Release.a
  group MICO/Library
    ../../../../MICO/Library/: MICOConfig.c mxchipWNet_cm3_sdio.a mxchipWNet_cm3_spi.a
    ../../../../MICO/Library/EasyCloud/: MicoEasyCloudService_debug.a MicoEasyCloudService_release.a
  group Support
    ../../../../Support/: AESUtils.c HTTPUtils.c MDNSUtils.c RingBufferUtils.c SecurityUtils.c SHAUtils.c SocketUtils.c StringUtils.c TimeUtils.c TLVUtils.c URLUtils.c
  group External/JSON-C
    ../../../../External/JSON-C/: arraylist.c debug.c json_object.c json_tokener.c json_util.c linkhash.c printbuf.c
  group External/SHAUtils
    ../../../../External/SHAUtils/: hkdf.c hmac.c sha1.c sha224-256.c sha384-512.c usha.c
  group External/curve25519_donna
    ../../../../External/Curve25519/: curve25519-donna.c
  group Platform/Cortex-M3
    ../../../../Platform/Cortex-M3/: crt0_RVMDK.c hardfault.c
  group Platform/RVMDK
    ../../../../Platform/RVMDK/: Retarget.c thread_safe.c memory_debugger.lib memory_debugger.c
  group Platform/Drivers/MFiAuth
    ../../../../Platform/Drivers/MicoDriverMFiAuth/: MicoDriverMFiAuth.a
  group Platform/Drivers/SPI_Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/MCU
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/STM32F2xx
    ../../../../Platform/MCU/STM32F2xx/: platform_init.c
  group Platform/MCU/STM32F2xx/RVMDK
    ../../../../Platform/MCU/STM32F2xx/RVMDK/: startup_stm32f2xx_RVMDK.s
  group Platform/MCU/STM32F2xx/wlan_bus_driver
    ../../../../Platform/MCU/STM32F2xx/wlan_bus_driver/: read_wifi_firmware.c wlan_bus_sdio.c wlan_bus_spi.c wlan_platform.c
  group Platform/MCU/STM32F2xx/peripherals/Libraries
    ../../../../Platform/MCU/STM32F2xx/peripherals/Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
    ../../../../Platform/MCU/STM32F2xx/peripherals/Libraries/: system_stm32f2xx.c
  group Platform/MCU/STM32F2xx/peripherals
    ../../../../Platform/MCU/STM32F2xx/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
target MiCOKit-F205 (ARM-ADS)
  device: STM32F205RGTx STMicroelectronics
  pack: Keil.STM32F2xx_DFP.2.1.0
  cpu: as above
  output: COM.WECHAT.SPP.axf
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe --bin  ..\..\..\..\Build\COM.WECHAT.SPP\MiCOKit-F205\Obj_RVMDK\COM.WECHAT.SPP.axf --output ..\..\..\..\Build\COM.WECHAT.SPP\Output\MiCOKit-F205\COM.WECHAT.SPP.bin
  c flags: Optim=4 OneElfS=1 uC99=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER DEBUG
  c misc: --diag_suppress=1,1293
  c include: ..\..\..\..\Demos\COM.WECHAT.SPP;..\..\..\..\include;..\..\..\..\include\EasyCloud;..\..\..\..\MICO;..\..\..\..\Support;..\..\..\..\External;..\..\..\..\Board\MiCOKit-F205;..\..\..\..\Platform\include;..\..\..\..\Platform\Cortex-M3;..\..\..\..\Platform\Cortex-M3\CMSIS;..\..\..\..\Platform\Drivers\spi_flash;..\..\..\..\Platform\MCU\STM32F2xx\peripherals;..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc;..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries
  memory RVCT4: ROM 0x8008000 size 0xf4000
  memory RVCT9: RAM 0x20000000 size 0x20000
  link misc: --diag_warning=6218,6654,6238 --diag_suppress=6238
