# IAR project Bootloader.ewp, settings and files
configuration MiCOKit-3162 (ARM)
  General.OGChipSelectEditMenu: STM32F205ZG ST STM32F205ZG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; SIZE_OPTIMIZE; DEBUG; BOOTLOADER; NO_MICO_RTOS
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-3162; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M3; ..\..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\External\FatFs\src\drivers; ..\..\..\..\External\FatFs\src; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\MCU
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Bootloader.bin
  ILINK.IlinkOutputFile: COM.MXCHIP.SPP.out
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3162\bootloaderLinkerForIAR.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MICOKit-F205 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; BOOTLOADER; NO_MICO_RTOS
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-F205; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M3; ..\..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\External\FatFs\src\drivers; ..\..\..\..\External\FatFs\src; ..\..\..\..\Platform\Drivers\spi_flash; ..\..\..\..\Platform\MCU
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-F205\bootloaderLinkerForIAR.icf
configuration MiCOKit-3161 (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; DEBUG; BOOTLOADER; NO_MICO_RTOS
  ICCARM.CCIncludePath2: ..\..\..\..\Bootloader; ..\..\..\..\include; ..\..\..\..\MICO; ..\..\..\..\Support; ..\..\..\..\External; ..\..\..\..\Board\MiCOKit-3161; ..\..\..\..\Platform\include; ..\..\..\..\Platform\Cortex-M3; ..\..\..\..\Platform\Cortex-M3\CMSIS; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_StdPeriph_Driver\inc; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries; ..\..\..\..\Platform\MCU\STM32F2xx\peripherals\Libraries\STM32F2xx_HAL_Driver\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Core\Inc; ..\..\..\..\Platform\Drivers\STM32_USB_Host_Library\Class\MSC\Inc; ..\..\..\..\External\FatFs\src\drivers; ..\..\..\..\External\FatFs\src; ..\..\..\..\Platform\Drivers\spi_flash
  ILINK.IlinkIcfFile: ..\..\..\..\Board\MiCOKit-3161\bootloaderLinkerForIAR.icf
  group Board/MiCOKit-3161
    ../../../../Board/MiCOKit-3161/: platform.c platform.h platform_common_config.h platform_spi_flash.c
  group Board/MiCOKit-3162
    ../../../../Board/MiCOKit-3162/: platform.c platform.h platform_config.h
  group Board/MICOKit-F205
    ../../../../Board/MiCOKit-F205/: platform.c platform.h platform_config.h
  group Bootloader
    ../../../../Bootloader/: BootloaderEntrance.c Getline.c menu.c MicoDefaults.h Update_for_OTA.c ymodem.c
  group include
    ../../../../include/: MICO.h MicoAES.h MicoAlgorithm.h MicoPlatform.h MICORTOS.h MicoSocket.h MicoSRPServer.h MicoWlan.h
  group include/MicoDriver
    ../../../../include/MicoDrivers/: MicoDriverAdc.h MicoDriverGpio.h MicoDriverI2c.h MicoDriverMFiAuth.h MicoDriverPwm.h MicoDriverRng.h MicoDriverRtc.h MicoDriverSpi.h MicoDriverUart.h MicoDriverWdg.h
  group Platform/Cortex-M3
    ../../../../Platform/Cortex-M3/: crt0_EWARM.c hardfault.c
  group Platform/Drivers/SPI Flash
    ../../../../Platform/Drivers/spi_flash/: spi_flash.c spi_flash_platform.c
  group Platform/EWARM
    ../../../../Platform/EWARM/: Retarget.c
  group Platform/MCU
    ../../../../Platform/MCU/: mico_platform_common.c wlan_platform_common.c
  group Platform/MCU/STM32F2xx
    ../../../../Platform/MCU/STM32F2xx/: platform_init.c
  group Platform/MCU/STM32F2xx/EWARM
    ../../../../Platform/MCU/STM32F2xx/EWARM/: startup_stm32f2xx_bootloader_EWARM.s
  group Platform/MCU/STM32F2xx/Peripherals
    ../../../../Platform/MCU/STM32F2xx/peripherals/: paltform_rtc.c platform_adc.c platform_flash.c platform_gpio.c platform_i2c.c platform_mcu_powersave.c platform_pwm.c platform_rng.c platform_spi.c platform_uart.c platform_watchdog.c
  group Platform/MCU/STM32F2xx/Peripherals/Libraries
    ../../../../Platform/MCU/STM32F2xx/peripherals/Libraries/: stm32f2xx_conf.h system_stm32f2xx.c
  group Platform/MCU/STM32F2xx/Peripherals/Libraries/STM32F2xx_HAL_Driver
    ../../../../Platform/MCU/STM32F2xx/peripherals/Libraries/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_hcd.c stm32f2xx_ll_usb.c
  group Platform/MCU/STM32F2xx/Peripherals/Libraries/STM32F2xx_StdPeriph_Driver
    ../../../../Platform/MCU/STM32F2xx/peripherals/Libraries/STM32F2xx_StdPeriph_Driver/src/: misc.c stm32f2xx_adc.c stm32f2xx_can.c stm32f2xx_crc.c stm32f2xx_cryp.c stm32f2xx_cryp_aes.c stm32f2xx_cryp_des.c stm32f2xx_cryp_tdes.c stm32f2xx_dac.c stm32f2xx_dbgmcu.c stm32f2xx_dcmi.c stm32f2xx_dma.c stm32f2xx_exti.c stm32f2xx_flash.c stm32f2xx_fsmc.c stm32f2xx_gpio.c stm32f2xx_hash.c stm32f2xx_hash_md5.c stm32f2xx_hash_sha1.c stm32f2xx_i2c.c stm32f2xx_iwdg.c stm32f2xx_pwr.c stm32f2xx_rcc.c stm32f2xx_rng.c stm32f2xx_rtc.c stm32f2xx_sdio.c stm32f2xx_spi.c stm32f2xx_syscfg.c stm32f2xx_tim.c stm32f2xx_usart.c stm32f2xx_wwdg.c
  group Support
    ../../../../Support/: RingBufferUtils.c StringUtils.c
